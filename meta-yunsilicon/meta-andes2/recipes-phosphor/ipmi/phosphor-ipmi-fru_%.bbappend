DEPENDS:append:andes2 = " andes2-yaml-config"

IPMI_FRU_YAML:andes2 = "${STAGING_DIR_HOST}${datadir}/andes2-yaml-config/ipmi-fru-read.yaml"
IPMI_FRU_PROP_YAML:andes2 = "${STAGING_DIR_HOST}${datadir}/andes2-yaml-config/ipmi-extra-properties.yaml"
