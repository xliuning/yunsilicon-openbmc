FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Change-SEL-delete-default-folder-for-ubi.patch"

