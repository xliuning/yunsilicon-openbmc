FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Uboot-only-stop-when-press-Ctrl-C.patch"

